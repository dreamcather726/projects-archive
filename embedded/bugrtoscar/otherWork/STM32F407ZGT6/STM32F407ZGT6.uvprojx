# Keil uVision project STM32F407ZGT6.uvprojx, settings and files
target STM32F407ZGT6 (6220000::V6.22::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(16000000) ELITTLE
  output: STM32F407ZGT6 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F407xx,STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\CMSIS\Core\Include;.\CMSIS\Device\Include;.\App\Inc;.\Config\Inc;.\Common\Inc;.\BSP\Inc;.\Libraries\IMU\Inc;.\Libraries\StepperMotor\Inc;.\RTOS\FreeRTOS-Kernel\include;.\RTOS\FreeRTOS-Kernel\portable\GCC\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ./App/Src/: main.c app.c app_tasks.c freertos_hooks.c host_protocol.c mecanum_chassis.c
    ./App/Inc/: app.h app_tasks.h host_protocol.h mecanum_chassis.h
  group Configuration
    ./Config/Inc/: app_config.h FreeRTOSConfig.h stm32f4xx_conf.h
  group Common
    ./Common/Inc/: project_status.h
  group BSP
    ./BSP/Src/: bsp.c bsp_uart.c
    ./BSP/Inc/: bsp.h bsp_uart.h
  group RTOS/FreeRTOS Kernel
    ./RTOS/FreeRTOS-Kernel/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c
    ./RTOS/FreeRTOS-Kernel/portable/GCC/ARM_CM4F/: port.c
    ./RTOS/FreeRTOS-Kernel/include/: FreeRTOS.h task.h queue.h
  group Libraries/IMU
    ./Libraries/IMU/Src/: imu.c
    ./Libraries/IMU/Inc/: imu.h
  group Libraries/StepperMotor
    ./Libraries/StepperMotor/Src/: dianji_uart.c Emm_V5.c fifo.c
    ./Libraries/StepperMotor/Inc/: dianji_uart.h Emm_V5.h fifo.h
  group Libraries/STM32F4xx StdPeriph
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_dma.c
    ./Libraries/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx.h stm32f4xx_rcc.h stm32f4xx_gpio.h stm32f4xx_usart.h stm32f4xx_dma.h
  group CMSIS Device
    ./CMSIS/Device/Source/: system_stm32f4xx.c startup_stm32f407xx.s
software components: CMSIS:CORE 6.1.0
