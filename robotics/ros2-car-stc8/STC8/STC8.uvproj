# Keil uVision project STC8.uvproj, settings and files
target STC8_4Motor_AOnly (MCS-51)
  device: 8XC52 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x1FFF) CLOCK(24000000)
  output: STC8_4Motor_AOnly +hex
  c flags: Optimize=9
  c define: STC_MOTOR_APP,MOTOR_ENCODER_AB=0
  c include: .\Firmware\Include;.\Peripheral\Include
  group Application
    ./Firmware/Source/: main.c control_logic.c motor_driver.c protocol.c serial_link.c encoder.c parameters.c
  group Headers
    ./Firmware/Include/: board_config.h app.h control_logic.h motor_driver.h project_types.h protocol.h serial_link.h encoder.h motor_channels.h parameters.h
  group Startup
    ./Firmware/Startup/: STARTUP.A51
  group Peripheral - Motor adapter
    ./Peripheral/Source/: motor_hal.c
    ./Peripheral/Include/: motor_hal.h config.h STC8xxxx.H
